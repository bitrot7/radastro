options:
  parameters:
    author: q
    generate_options: qt_gui
    id: h_line
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N_integrate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: cf
  id: variable
  parameters:
    value: wb_center + fshift
  states: {}
- name: chan_rate
  id: variable
  parameters:
    value: int(samp_rate)*interp / decim
  states: {}
- name: decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: disp_fac
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fft_size_0
  id: variable
  parameters:
    value: 1024*8
  states: {}
- name: fshift
  id: variable_qtgui_range
  parameters:
    label: Freq Shift
    start: '-8e6'
    step: 100e3
    stop: 8e6
    value: '0'
  states: {}
- name: input_vec
  id: variable
  parameters:
    value: int(1024)
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain dB
    rangeType: int
    start: '0'
    step: '1'
    stop: '11'
    value: '0'
  states: {}
- name: samp_delay
  id: variable_qtgui_range
  parameters:
    label: Sample Delay Channel 1
    rangeType: int
    start: '-25000'
    step: '1'
    stop: '25000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(6e6)
  states: {}
- name: wb_center
  id: variable_qtgui_range
  parameters:
    label: WB CenterFreq
    start: 100e3
    step: '1'
    stop: 2e9
    value: 1421.4e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1420.405e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_92mhz2
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/q/src/sge/radio_astronomy/files/radastro_2026-05-03_19-46-12.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: input_vec
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: input_vec
    type: float
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 192.168.1.234
    header: '0'
    payloadsize: '1472'
    port: '4571'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: This guy is bad at naming shit.  Decimation is actually just your integration (averaging factor)
  states: {}
- name: note_1
  id: note
  parameters:
    note: Size of the vector going into ra_vave and also coming out, however it will take N_integrate samples for each sample given.
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: cf
    fftsize: '512'
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    update_time: '10'
    vlen: '1024'
    x_start: 1421.4 - 3
    x_step: 6 / 1023
  states: {}
- name: rad_astro_avg_0
  id: rad_astro_avg
  parameters:
    alpha: '1.0'
    avgType: '0'
    beta: '1.0'
    delta: '1.0'
    gamma: '1.0'
    numAvgs: N_integrate
    vlen: '1024'
  states: {}
- name: rad_astro_avg_0_0
  id: rad_astro_avg
  parameters:
    alpha: '1.0'
    avgType: '1'
    beta: '1.0'
    delta: '1.0'
    gamma: '1.0'
    numAvgs: N_integrate
    vlen: '1024'
  states: {}
- name: rad_astro_avg_1
  id: rad_astro_avg
  parameters:
    alpha: '1.0'
    avgType: '0'
    beta: '1.0'
    delta: '1.0'
    gamma: '1.0'
    numAvgs: '10'
    vlen: '1024'
  states: {}
- name: rad_astro_avg_1_0
  id: rad_astro_avg
  parameters:
    alpha: '1.0'
    avgType: '1'
    beta: '1.0'
    delta: '1.0'
    gamma: '1.0'
    numAvgs: '10'
    vlen: '1024'
  states: {}
- name: rad_astro_filewriter_0
  id: rad_astro_filewriter
  parameters:
    filename: files/radastro_
    vlen: '1024'
  states: {}
- name: rad_astro_filewriter_0_0
  id: rad_astro_filewriter
  parameters:
    filename: files/radastro_rms_
    vlen: '1024'
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: 6000e3
    biasT: 'False'
    center_freq: cf
    center_freq0: '0'
    center_freq1: '0'
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '35'
    if_gRdB0: '40'
    if_gRdB1: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gRLNA0: rf_gain
    rf_gRLNA1: rf_gain
    rf_gR_mode: LNA
    rf_gRdB: '0'
    rf_gRdB0: rf_gain
    rf_gRdB1: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    rspduo_mode: Single Tuner
    sample_rate: samp_rate
    sample_rate_non_single_tuner: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    showports: 'False'
    stream_tags: 'False'
    synchronous_updates: 'False'
  states: {}
- name: zeromq_push_sink_1
  id: zeromq_push_sink
  parameters:
    address: tcp://192.168.1.209:4571
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_mag_0, '0', rad_astro_avg_0, '0']
- [blocks_complex_to_mag_squared_0, '0', rad_astro_avg_0_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_1_0_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [blocks_vector_to_stream_0, '0', zeromq_push_sink_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rad_astro_avg_0, '0', rad_astro_avg_1, '0']
- [rad_astro_avg_0_0, '0', rad_astro_avg_1_0, '0']
- [rad_astro_avg_1, '0', rad_astro_filewriter_0, '0']
- [rad_astro_avg_1_0, '0', rad_astro_filewriter_0_0, '0']
- [sdrplay3_rspduo_0, '0', blocks_stream_to_vector_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
